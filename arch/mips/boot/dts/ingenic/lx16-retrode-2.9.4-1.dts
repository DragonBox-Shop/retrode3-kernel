/dts-v1/;

#define LX16_REV 	2	// main board revision
#define LX16_W		2	// 0 = none; WLAN and Bluetooth: 1 = QCom, 2 = ESP32
#define APPLICATION	294

#include "lx16.dts"

/ {
// broken board 2.9.4#1
	model = "Openpandora Retrode-2.9.4#1";
};

&retrode3 {
		// NOTE: x1600 pins can be either pull-up or pull-down (only some PC can pull down). Or bias-disable.
		// rewire D2 and D10
		data { /* D0 .. D15 */
			pins = "PA8", "PA9", "PC24", "PA11", "PA12", "PA13", "PA14", "PA15",
			       "PA16", "PA17", "PC25", "PA19", "PA20", "PA21", "PA22", "PA23";
			/delete-property/ bias-pull-up;
			bias-disable;	/* PC24/25 can't do pull-up
		};
};
